Commit message: URDF and RViz are finally working! Happy 4th y'all!

File: urdf/rover_2_0.urdf (robot description, URDF)
Before this commit: robot Rover 2.0, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=1.0 2.0 .5
